Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-01-19T22:53:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 19 22:53:55 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{12D3A014-BC9F-49F0-9045-8069B4BD560A}\ifc * Database version: 5507 * Database creation date: Wed Jan 19 22:53:55 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 19 22:53:55 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 19 22:53:55 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 571522730005 Washbasin faucet, 571522730005(2022):571522730005 Washbasin faucet:530358
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 189.946 mm; NominalHeight: 185 mm; NominalWidth: 85.7668 mm
Type - General - Author: BIMStone; BIMObjectName: 571522730005(2022); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Kitchen faucet with high spout.; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/01/2022
Type - Green Building Properties - Approval ABP: PA-IX 38026/IO; Backflow Prevention EN1717: AA; EAN Number: 4057304018275; EN Standard: EN 817; Sales Package dimensions (LxWxH): 374 x 214 x 116; Sales Package gross weight: 2.5 kg; Sales Package package weight: 0.3419 kg; URL ABP: http://static.hansa.com/ABP/571522730005/original; URL Declaration of Conformity: http://static.hansa.com/DoC/571522730005; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - Catalog Drawing URL: http://static.hansa.com/catdrw/571522730005; Dimension Drawing URL: http://static.hansa.com/dimdrw/571522730005; FDV Document URL: http://www.hansa.com/datasheet/571522730005/en/fdv; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/571522730005; Item Type: Sales item; Manufacturer: HANSA; Market: International;Germany;Austria;Belgium;Netherlands;Czech Republic;Slovakia;Italy; Mobile Product Information URL: http://mpi.hansa.com/571522730005; Model: 571522730005 Washbasin faucet; Name_en: 571522730005 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 571522730005; Product Family: HANSASTELA Eco; Product Image URL: http://static.hansa.com/image/571522730005; Product URL: http://static.hansa.com/571522730005; Spare-Part Information URL: http://static.hansa.com/sp/571522730005; Technical DataSheet URL: http://www.hansa.com/datasheet/571522730005/en; Type Name: 571522730005 Washbasin faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: PCA® - constant flow rate regardless of pressure variations; Connection: Flexible inlet pipes; Connection Size: G3/8; Extensions: Pop-up waste with draw-rod; Flow Rate At 300kPa With Flow Controller: 0.00247203 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 25 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Noise Class: I (ISO 3822); Spout Projection: 134 mm; Spout Type: Swivel spout; Surface treatment: Chrome; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 571522730005(2022); Features: Single-lever;Green Building; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 571522730005; Name: 571522730005 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 85x190x185 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 571522730005; Manufacturer: HANSA
Pset_DistributionFlowElementCommon - Reference: 571522730005 Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0683926 m2; Volume: 0.00301811 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 571522730005(2022): 571522730005 Washbasin faucet; Family and Type: 571522730005(2022): 571522730005 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 571522730005(2022): 571522730005 Washbasin faucet; Type Id: 571522730005(2022): 571522730005 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
